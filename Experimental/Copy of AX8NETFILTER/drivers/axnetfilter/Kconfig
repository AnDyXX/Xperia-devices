## Experimental/Copy of AX8NETFILTER/drivers/axnetfilter/Kconfig
```kconfig
config AX8_NETFILTER
bool "X8 NETFILTER Hack"


config AX8_NETFILTER_MODULE
tristate "X8 NETFILTER Module"
```
